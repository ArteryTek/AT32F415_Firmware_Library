# Keil uVision project composite_vcp_keyboard.uvprojx, settings and files
target composite_vcp_keyboard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F415RCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: composite_vcp_keyboard +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1
  c include: ..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\at32f415_board;..\inc;..\..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\..\middlewares\usbd_class\composite_cdc_keyboard
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: at32f415_clock.c at32f415_int.c main.c
  group bsp
    ../../../../../at32f415_board/: at32f415_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f415_crm.c at32f415_exint.c at32f415_gpio.c at32f415_misc.c at32f415_pwc.c at32f415_usart.c at32f415_usb.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
  group usbd_driver
    ../../../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../../middlewares/usbd_class/composite_cdc_keyboard/: cdc_keyboard_class.c cdc_keyboard_desc.c
  group readme
    ../: readme.txt
