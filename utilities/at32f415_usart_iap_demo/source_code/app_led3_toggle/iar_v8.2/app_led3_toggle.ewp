# IAR project app_led3_toggle.ewp, settings and files
configuration app_led3_toggle (ARM, debug)
  General.OGChipSelectEditMenu: AT32F415RCT7_v2 ArteryTek -AT32F415RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F415RCT7; USE_STDPERIPH_DRIVER; AT_START_F415_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32f415_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at32f403a_app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32F415xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../project/at32f415_board/: at32f415_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f415.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f415_crm.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_tmr.c at32f415_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f415_clock.c at32f415_int.c iap.c main.c tmr.c usart.c
