# Keil uVision project app_led3_toggle.uvprojx, settings and files
target app_led3_toggle (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F415RCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.0
  cpu: IROM(0x08000000,0x3F0000) IRAM(0x20000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_led3_toggle +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1
  c include: ..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\project\at32f415_board;..\inc;..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\middlewares\usbd_class\hid_iap
  memory RVCT4: ROM 0x8005000 size 0x3b000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: at32f415_clock.c at32f415_int.c main.c hid_iap_user.c
  group bsp
    ../../../../../project/at32f415_board/: at32f415_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f415_crc.c at32f415_crm.c at32f415_usart.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_usb.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
  group usbd_driver
    ../../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group readme
    ../: readme.txt
