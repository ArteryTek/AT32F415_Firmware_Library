# IAR project project_l1.ewp, settings and files
configuration project_l1 (ARM)
  General.OGChipSelectEditMenu: AT32F415RCT7_v2 ArteryTek -AT32F415RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F415RCT7; USE_STDPERIPH_DRIVER; AT_START_F415_V1; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\inc; ..\..\..\..\project\at32f415_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project_l1.hex
  ILINK.IlinkOutputFile: project_l1.out
  ILINK.IlinkIcfFile: AT32F415xC_enduser.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../project/at32f415_board/: at32f415_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f415.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
  group fir_filter
    ./: fir_filter_symbol.o
  group firmware
    ../../../../libraries/drivers/src/: at32f415_crm.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c
  group readme
    ../: readme.txt
  group user
    ../src/: arm_fir_data.c at32f415_clock.c at32f415_int.c main.c math_helper.c
