# IAR project run_in_boot_memory.ewp, settings and files
configuration run_in_boot_memory (ARM, debug)
  General.OGChipSelectEditMenu: AT32F415RCT7_v2 ArteryTek -AT32F415RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F415RCT7; USE_STDPERIPH_DRIVER; AT_START_F415_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\project\at32f415_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: run_in_boot_memory.bin
  ILINK.IlinkOutputFile: run_in_boot_memory.out
  ILINK.IlinkIcfFile: AT32F415xC_apmode.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../project/at32f415_board/: at32f415_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f415.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
  group firmware
    ../../../../libraries/drivers/src/: at32f415_crm.c at32f415_gpio.c at32f415_misc.c at32f415_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f415_clock.c at32f415_int.c main.c run_in_boot_memory.c
